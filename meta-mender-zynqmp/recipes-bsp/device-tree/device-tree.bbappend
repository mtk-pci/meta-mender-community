#https://hub.mender.io/t/yocto-how-to-build-mender-with-external-device-tree/423/11
RPROVIDES:${PN} = "kernel-devicetree"
